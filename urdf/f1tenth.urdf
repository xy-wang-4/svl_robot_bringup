Commit message: params

File: urdf/f1tenth.urdf (robot description, URDF)
Before this commit: robot f1tenth, 7 links, 6 joints
Links:
- link base_link: mass None -> 0.25
